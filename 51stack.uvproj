# Keil uVision project 51stack.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51stack +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\common;.\main;.\sensors
  group Source Group 1
    ./: STARTUP.A51
  group main
    ./main/: main.c main.h notice.txt
  group common
    ./common/: uart.c uart.h delay.c delay.h nixietube.c nixietube.h button.c button.h keyboard.c keyboard.h ledmatrix.c ledmatrix.h interrupt.c interrupt.h timer.c timer.h iic.c iic.h
  group sensors
    ./sensors/: at24c02.c at24c02.h
